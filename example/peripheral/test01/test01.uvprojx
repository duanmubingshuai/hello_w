# Keil uVision project test01.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: PHY6222 Generic
  pack: Keil.PHY62xx.0.0.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test01
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
