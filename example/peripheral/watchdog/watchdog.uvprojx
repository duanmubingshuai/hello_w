# Keil uVision project watchdog.uvprojx, settings and files
target watchdog (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PHY6222 Generic
  pack: Keil.PHY62xx.0.0.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: watchdog +hex
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/watchdog.axf
  AfterMake: fromelf.exe .\Objects\watchdog.axf --i32combined --output .\bin\watchdog.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP HCI_TL_NONE=1 OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 MAIN_HAS_NOARGC MAIN_HAS_NORETURN DEBUG_INFO=1 CFG_SLEEP_MODE=PWR_MODE_SLEEP
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;.\source;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\arch\cm0;..\..\..\components\ble\include;..\..\..\components\ble\controller;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\libraries\secure;..\..\..\components\osal\include;..\..\..\misc;..\..\..\components\driver\uart;..\..\..\components\driver\log;..\..\..\components\driver\adc;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\timer;..\..\..\components\driver\spi;..\..\..\components\libraries\cliface;..\..\..\components\driver\pwm;..\..\..\components\driver\kscan;..\..\..\components\driver\dma;..\..\..\components\driver\flash;..\..\..\components\driver\spiflash;..\..\..\components\driver\watchdog;.\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\watchdog.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group main
    ./source/: main.c OSAL_watchdog.c watchdog_demo.c watchdog_Main.c
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/watchdog/: watchdog.c
    ../../../components/driver/flash/: flash.c
  group jump
    ../../../misc/: jump_table.c
  group rf
    ../../../lib/: rf.lib
  group coremark
    ../../../components/coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group cli
    ../../../components/libraries/cliface/: cliface.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
